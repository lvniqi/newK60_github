# IAR project templete.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: MK60D10; DEBUG; URANUS
  ICCARM.CCIncludePath2: ..\..\..\Libraries\drivers\K\inc; ..\..\..\Libraries\startup\CoreSupport; ..\..\..\Libraries\startup\DeviceSupport\IAR-ARM; ..\..\..\Libraries\startup\DeviceSupport; ..\..\..\Libraries\devices\inc; ..\src\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: templete.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60DN512xxx10 Freescale MK60DN512xxx10
  ICCARM.CCDefines: NDEBUG; MK60D10
  ICCARM.CCIncludePath2: ..\..\..\..\Libraries\drivers\K\inc; ..\..\..\..\Libraries\startup\CoreSupport; ..\..\..\..\Libraries\startup\DeviceSupport\IAR-ARM; ..\..\..\..\Libraries\startup\DeviceSupport
  ICCARM.CCOptStrategy: 0
  group drivers
    ../../../Libraries/drivers/K/src/: adc.c common.c cpuidy.c dma.c flexbus.c ftm.c gpio.c i2c.c lptmr.c pdb.c pit.c rtc.c sd.c spi.c systick.c tsi.c uart.c wdog.c
  group NFR24l01
    ../../../Libraries/devices/src/: nrf24l01.c spi_bus_ops.c
  group startup
    ../../../Libraries/startup/DeviceSupport/IAR-ARM/: startup_MK60D10.s
    ../../../Libraries/startup/DeviceSupport/: system_MK60D10.c
  group user
    ../src/: angle.c angle.h board.h init.c init.h main.c myadc.c myadc.h oled.c oled.h speed.c speed.h speed_control.c speed_control.h speed_counter.c speed_counter.h Threads.c Threads.h
    ../../../Libraries/devices/src/: my2401.c
    ../../../Libraries/devices/inc/: my2401.h
