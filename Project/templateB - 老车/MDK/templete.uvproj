# Keil uVision project templete.uvproj, settings and files
target template (ARM-ADS)
  device: MK60DN512xxx10 Freescale Semiconductor
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") CLOCK(100000000) ELITTLE
  output: templete +hex
  AfterMake: fromelf --bin !L --output ./OBJ/flash/templete.bin
  c flags: Optim=1
  c define: MK60D10 RAVEN DEBUG
  c misc: --c99
  c include: ..\..\..\Libraries\startup\CoreSupport;..\..\..\Libraries\startup\DeviceSupport;..\..\..\Libraries\drivers\K\inc;..\..\..\Libraries\utilities\inc;..\..\..\Libraries\devices\inc;..\src;..\..\..\Libraries\znfat;..\..\..\Libraries\emWin\Include;..\..\..\Libraries\emWin\Sample\LCD_X
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group drivers
    ../../../Libraries/drivers/K/src/: adc.c can.c common.c cpuidy.c crc.c dac.c dma.c enet.c flexbus.c ftm.c gpio.c i2c.c lptmr.c pdb.c pit.c rtc.c sd.c spi.c systick.c tsi.c uart.c vref.c wdog.c
    ../../../Libraries/drivers/K/src/flash/lib/: MK_P32_50MHZ.lib MK_P512.lib
  group hardware
    ../src/: oled.c bluetooth.c oled.h bluetooth.h
  group startup
    ../../../Libraries/startup/DeviceSupport/: system_MK60D10.c
    ../../../Libraries/startup/DeviceSupport/MDK-ARM/: startup_MK60D10.s
  group user
    ../src/: main.c head.h
  group control
    ../src/: dianji.c duoji.c timer.c myadc.c encoder.c beep.c road.c dianji.h duoji.h timer.h myadc.h encoder.h beep.h road.h
  group version
    ../src/: version.txt
  group flash
    ../src/: flash.c flash.h
