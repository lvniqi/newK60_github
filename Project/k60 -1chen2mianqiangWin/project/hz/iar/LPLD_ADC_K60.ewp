# IAR project LPLD_ADC_K60.ewp, settings and files
configuration RAM (ARM, debug)
  General.OGChipSelectEditMenu: MK60DX256xxx10 Freescale MK60DX256xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR; LPLD_K60
  ICCARM.CCIncludePath2: ..\app; ..\..\..\lib\common; ..\..\..\lib\cpu; ..\..\..\lib\cpu\headers; ..\..\..\lib\drivers\adc16; ..\..\..\lib\drivers\enet; ..\..\..\lib\drivers\lptmr; ..\..\..\lib\drivers\mcg; ..\..\..\lib\drivers\pmc; ..\..\..\lib\drivers\rtc; ..\..\..\lib\drivers\uart; ..\..\..\lib\drivers\wdog; ..\..\..\lib\platforms; ..\..\..\lib\LPLD; ..\..\..\lib\iar_config_files
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LPLD_ADC_K60.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\..\lib\iar_config_files\64KB_Ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FLASH (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: ..\..\..\lib\iar_config_files\128KB_Pflash_128KB_Dflash.icf
  group app
    ../app/: control.c control.h head.h isr.h main.c trycontrol.c tryspeed.c
  group bluetooth
    ../app/: bluetooth.c bluetooth.h
  group dma
    ../app/: dma.c dma.h
  group dma/lib/common
    ../../../lib/common/: alloc.c assert.c assert.h common.h io.c io.h memtest.c memtest.h printf.c queue.c queue.h startup.c startup.h stdlib.c stdlib.h uif.c uif.h
  group dma/lib/cpu
    ../../../lib/cpu/: arm_cm4.c arm_cm4.h crt0.s dma_channels.h start.c start.h sysinit.c sysinit.h vectors.c vectors.h
  group dma/lib/cpu/headers
    ../../../lib/cpu/headers/: MK10DZ10.h MK20DZ10.h MK30DZ10.h MK40DZ10.h MK50DZ10.h MK51DZ10.h MK52DZ10.h MK53DZ10.h MK60DZ10.h
  group dma/lib/drivers/adc16
    ../../../lib/drivers/adc16/: adc16.c adc16.h
  group dma/lib/drivers/enet
    ../../../lib/drivers/enet/: enet.c enet.h eth.h eth_phy.c eth_phy.h mii.c mii.h nbuf.c nbuf.h
  group dma/lib/drivers/lptmr
    ../../../lib/drivers/lptmr/: lptmr.c lptmr.h
  group dma/lib/drivers/pmc
    ../../../lib/drivers/pmc/: pmc.c pmc.h
  group dma/lib/drivers/rtc
    ../../../lib/drivers/rtc/: rtc.c rtc.h
  group dma/lib/drivers/uart
    ../../../lib/drivers/uart/: uart.c uart.h
  group dma/lib/drivers/wdog
    ../../../lib/drivers/wdog/: wdog.c wdog.h
  group dma/lib/LPLD
    ../../../lib/LPLD/: HAL_ADC.c HAL_ADC.h HAL_Def.h HAL_eDMA.c HAL_eDMA.h HAL_FTM.c HAL_FTM.h HAL_GPIO.c HAL_GPIO.h HAL_MCG.c HAL_MCG.h HAL_PIT.c HAL_PIT.h HAL_SPI.c HAL_SPI.h HAL_UART.c HAL_UART.h
  group dma/lib/platform
    ../../../lib/platforms/: k60_card.h
  group OLED
    ../app/: OLED.c OLED.h
