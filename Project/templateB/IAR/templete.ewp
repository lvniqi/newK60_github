# IAR project templete.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: MK60D10; DEBUG
  ICCARM.CCIncludePath2: ..\..\..\Libraries\drivers\K\inc; ..\..\..\Libraries\devices\inc; ..\..\..\Libraries\startup\CoreSupport; ..\..\..\Libraries\startup\DeviceSupport\IAR-ARM; ..\..\..\Libraries\startup\DeviceSupport
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: templete.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60DN512xxx10 Freescale MK60DN512xxx10
  ICCARM.CCDefines: NDEBUG; MK60D10
  ICCARM.CCIncludePath2: ..\..\..\..\Libraries\drivers\K\inc; ..\..\..\..\Libraries\startup\CoreSupport; ..\..\..\..\Libraries\startup\DeviceSupport\IAR-ARM; ..\..\..\..\Libraries\startup\DeviceSupport
  ICCARM.CCOptLevel: 3
  group (top)
    ../src/: flash.c flash.h
  group control
    ../src/: beep.c dianji.c dianji.h duoji.c duoji.h encoder.c myadc.c road.c timer.c
  group drivers
    ../../../Libraries/drivers/K/src/: adc.c can.c common.c cpuidy.c crc.c dac.c dma.c enet.c flexbus.c ftm.c gpio.c i2c.c lptmr.c pdb.c pit.c rtc.c sd.c spi.c systick.c tsi.c uart.c vref.c wdog.c
  group hardware
    ../src/: bluetooth.c oled.c
  group startup
    ../../../Libraries/startup/DeviceSupport/IAR-ARM/: startup_MK60D10.s
    ../../../Libraries/startup/DeviceSupport/: system_MK60D10.c
  group user
    ../src/: head.h main.c
  group version
    ../src/: version.txt
